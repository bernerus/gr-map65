options:
  parameters:
    author: Christer Bernérus, SM6FBQ
    description: Test signal (noise plus a carrier) for MAP65/EME65/QMAP over UDP
    generate_options: no_gui
    id: map65_test_signal
    output_language: python
    run_options: run
    title: MAP65 test signal
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Must match the sample rate selected in MAP65/EME65/QMAP
    value: '96000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 144.125e6
  states: {}
- name: carrier
  id: analog_sig_source_x
  parameters:
    amp: '0.0003'
    comment: Carrier 10 kHz above the centre, well above the noise
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amp: '0.0014'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    comment: MAP65/EME65/QMAP need the data in real time
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: map65_udp_sink
  id: map65_udp_sink
  parameters:
    center_freq: center_freq
    host: 127.0.0.1
    inverted: 'False'
    port: '50004'
    samp_rate: samp_rate
    sample_format: int16
    scale: '32767'
    xpol: 'False'
  states: {}

connections:
- [add, '0', throttle, '0']
- [carrier, '0', add, '0']
- [noise, '0', add, '1']
- [throttle, '0', map65_udp_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
